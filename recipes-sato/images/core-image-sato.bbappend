IMAGE_INSTALL += "helloworld-m"
IMAGE_INSTALL += "helloworld-a"
IMAGE_INSTALL += "helloworld-c"
IMAGE_INSTALL += "helloworld-o"
